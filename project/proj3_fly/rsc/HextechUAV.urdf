Commit message: Project update

File: project/proj3_fly/rsc/HextechUAV.urdf (robot description, URDF)
Before this commit: robot HextechUAV, 6 links, 5 joints
Joints:
- joint Zaxis2Xaxis: limit lower=-18 upper=16 effort=0.0 velocity=100.0 -> lower=-100 upper=100 effort=0.0 velocity=100.0
